FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Signals-include-cstdint-for-uintptr_t.patch;striplevel=2"
