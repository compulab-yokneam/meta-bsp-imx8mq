FILESEXTRAPATHS_prepend := "${THISDIR}/compulab/imx8mq:"

include compulab/imx8mq.inc

COMPATIBLE_MACHINE = "cl-som-imx8"
