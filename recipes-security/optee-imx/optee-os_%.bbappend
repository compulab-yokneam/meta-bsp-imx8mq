FILESEXTRAPATHS:prepend := "${THISDIR}/compulab/imx8mq:"

require compulab/imx8mq.inc
COMPATIBLE_MACHINE = "cl-som-imx8"
